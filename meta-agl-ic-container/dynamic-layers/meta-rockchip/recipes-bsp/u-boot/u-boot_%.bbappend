RK_CONSOLE_DEVICE:aglcontainerguest = ""
NONFITDT:aglcontainerguest = ""
